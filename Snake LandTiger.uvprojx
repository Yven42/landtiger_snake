# Keil uVision project Snake LandTiger.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Landtiger_test1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Application
    ./: main.c globals.c ISR.c Print.c Set.c Eat-Death.c
  group Board Support
    ./: ADC_LandTiger.c Buttons_LandTiger.c GLCD_LandTiger.c LED_LandTiger.c Board_Joystick.h Joystick_MCB1700.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
